# Repository Candlelight-systems/pcb_mpp (continued)

## EAGLE design alltogether_8.2_4w.brd (continued)

Schematic: alltogether_8.2_4w.sch, sheet 10, DAC 1

Parts:
C257, C263, C264, C265, C267, C268, C269: 0.1u; 0402-CAP
C258: 2.2u; 0402-CAP
C259, C260, C261, C262: 10u; 0805
C266: 1u; 0402-CAP
R330, R331, R332: 10k; 0402-RES
TP4, TP5, TP6: TEST-POINT3; PAD.03X.03
U22: AP2202-ADJ; SOT23-5
U23: REF3225AMDBVREPG4; SOT95P280X145-6N
U24: DAC7718SRGZRQFP; QFP50P1200X1200X160-64N

Connections:
3.3V2: C258.1, C266.2, C267.1, C269.2, R330.1, R331.1, R332.2, U22.5 (OUT), U23.4 (IN), U24.24 (DVDD), U24.55 (IOVDD), U24.56 (DVDD_2)
AVDD: C257.1, C259.1, C261.1, C263.1, C264.1, U22.1 (IN), U22.3 (EN), U24.1 (AVDD), U24.48 (AVDD_2); also elsewhere on the board
AVSS: C260.2, C262.2, C265.2, C268.2, U24.12 (AVSS), U24.37 (AVSS_2); also elsewhere on the board
CS_DAC2: R331.2, U24.58 (~CS); also elsewhere on the board
DAC1: U24.11 (VOUT-0); also elsewhere on the board
DAC2: U24.7 (VOUT-1); also elsewhere on the board
DAC3: U24.6 (VOUT-2); also elsewhere on the board
DAC4: U24.4 (VOUT-3); also elsewhere on the board
DAC5: U24.45 (VOUT-4); also elsewhere on the board
DAC6: U24.43 (VOUT-5); also elsewhere on the board
DAC7: U24.42 (VOUT-6); also elsewhere on the board
DAC8: U24.38 (VOUT-7); also elsewhere on the board
GND: C257.2, C258.2, C259.2, C260.1, C261.2, C262.1, C263.2, C264.2, C265.1, C266.1, C267.2, C268.1, C269.1, U22.2 (GND), U23.1 (GND_F), U23.2 (GND_S), U24.8 (AGND-A), U24.9 (AGND-A_2), U24.25 (DGND), U24.28 (DGND_2), U24.40 (AGND-B), U24.41 (AGND-B_2), U24.50 (~USB/BTC), U24.54 (DGND_3), U24.62 (~LDAC), U24.63 (~WAKEUP); also elsewhere on the board
unnamed: R330.2, U24.51 (RSTSEL)
unnamed: R332.1, U24.20 (~CLR)
unnamed: TP4.P$1, U24.10 (OFFSET-A)
unnamed: TP5.P$1, U24.39 (OFFSET-B)
unnamed: TP6.P$1, U24.14 (VMON)
unnamed: U23.5 (OUT_S), U23.6 (OUT_F), U24.5 (REF-A), U24.44 (REF-B)
REFEN: U23.3 (ENABLE); also elsewhere on the board
RESETDAC: U24.21 (~RST); also elsewhere on the board
SCLK: U24.57 (SCLK); also elsewhere on the board
SDI: U24.59 (SDI); also elsewhere on the board
SDO: U24.61 (SDO); also elsewhere on the board

Schematic: alltogether_8.2_4w.sch, sheet 11

Parts:
C270, C271: 1n; 0402-CAP
D163, D165: BAT20JFILM; SOD-323
D164, D166: GREEN; LED-0603
K3, K18: AQW21SOP; SOP08
K5, K7, K19, K20: RT424005; RT2C/O
Q31, Q32: MOSFET-NCHANNELAO3404A; SOT23-3
R9, R10, R341, R342: 330; 0402-RES
R343, R347: 47; 0402-RES
R344, R346, R348, R350: 10k; 0402-RES
R345, R349: 100k; 0402-RES
TVS3, TVS4: TVS_DIODE_SOD-323; SOD-323
X5, X6, X11, X12: SPTAF1/5-3.5
X7, X8, X9, X10, X66, X67: SPTAF1/4-3.5

Connections:
3.3VD: R9.1, R10.1, R341.1, R342.1; also elsewhere on the board
GND: Q31.2 (S), Q32.2 (S), R345.1, R349.1, TVS3.CATH, TVS4.CATH; also elsewhere on the board
unnamed: K3.1 (A), R9.2
unnamed: K3.3 (A), R10.2
unnamed: K3.7 (D2), X6.P$1, X6.P$2, X6.P$9, X6.P$10
unnamed: K3.8 (D1), X6.P$7, X6.P$8
unnamed: K3.6 (D1), X5.P$7, X5.P$8
unnamed: K3.5 (D2), X5.P$1, X5.P$2, X5.P$9, X5.P$10
unnamed: X5.P$3, X5.P$4, X5.P$5, X5.P$6
unnamed: X6.P$3, X6.P$4, X6.P$5, X6.P$6
unnamed: K5.14 (S), X9.P$1, X9.P$2
unnamed: K5.11, X9.P$7, X9.P$8
unnamed: K7.24 (S), X10.P$3, X10.P$4
unnamed: K7.14 (S), X10.P$1, X10.P$2
unnamed: K7.21, X10.P$5, X10.P$6
unnamed: K5.21, X9.P$5, X9.P$6
unnamed: K5.24 (S), X9.P$3, X9.P$4
unnamed: K7.11, X10.P$7, X10.P$8
unnamed: C270.2, R343.2
unnamed: C271.2, R347.2
unnamed: K18.1 (A), R342.2
unnamed: K18.3 (A), R341.2
unnamed: K18.7 (D2), X12.P$1, X12.P$2, X12.P$9, X12.P$10
unnamed: K18.8 (D1), X12.P$7, X12.P$8
unnamed: K18.6 (D1), X11.P$7, X11.P$8
unnamed: K18.5 (D2), X11.P$1, X11.P$2, X11.P$9, X11.P$10
unnamed: K19.21, X8.P$5, X8.P$6
unnamed: K19.11, X8.P$7, X8.P$8
unnamed: K19.14 (S), X8.P$1, X8.P$2
unnamed: K20.21, X7.P$5, X7.P$6
unnamed: K20.11, X7.P$7, X7.P$8
unnamed: K20.14 (S), X7.P$1, X7.P$2
unnamed: K19.24 (S), X8.P$3, X8.P$4
unnamed: K20.24 (S), X7.P$3, X7.P$4
unnamed: X11.P$3, X11.P$4, X11.P$5, X11.P$6
unnamed: X12.P$3, X12.P$4, X12.P$5, X12.P$6
unnamed: D164.C, R346.2
unnamed: D166.C, R350.2
unnamed: D163.A, K5.A2 (2), K19.A2 (2), Q31.3 (D), R346.1, X66.P$7, X66.P$8
unnamed: D165.A, K7.A2 (2), K20.A2 (2), Q32.3 (D), R350.1, X67.P$7, X67.P$8
PWM1: K18.4 (K); also elsewhere on the board
PWM2: K18.2 (K); also elsewhere on the board
PWM3: K3.4 (K); also elsewhere on the board
PWM4: K3.2 (K); also elsewhere on the board
RELAY_LIGHT_1: Q31.1 (G), R344.2, R345.2; also elsewhere on the board
RELAY_LIGHT_1_R: R343.1, R344.1, TVS3.ANODE, X66.P$3, X66.P$4
RELAY_LIGHT_1_WRITE: C270.1, X66.P$1, X66.P$2; also elsewhere on the board
RELAY_LIGHT_4: Q32.1 (G), R348.2, R349.2; also elsewhere on the board
RELAY_LIGHT_4_R: R347.1, R348.1, TVS4.ANODE, X67.P$3, X67.P$4
RELAY_LIGHT_4_WRITE: C271.1, X67.P$1, X67.P$2; also elsewhere on the board
VCC: D163.C, D164.A, D165.C, D166.A, K5.A1 (1), K7.A1 (1), K19.A1 (1), K20.A1 (1), X66.P$5, X66.P$6, X67.P$5, X67.P$6; also elsewhere on the board

Schematic: alltogether_8.2_4w.sch, sheet 12

Parts:
C272, C273, C274, C275, C276, C277, C278, C279, C281, C282, C283: CAP0402-CAP; 0402-CAP
C280: 47u; 0805
R351, R352, R353, R354, R355, R356, R357, R358, R359, R360: RESISTOR0402-RES; 0402-RES
U25: ADS1148IPW; R-PDSO-G28
U26: LM94022; SOT65P210X110-5N
X68: 1751277

Connections:
3.3VD: C274.1, R354.2, U25.P$1 (DVDD); also elsewhere on the board
5V2: C276.1, R355.2, U25.P$22 (AVDD), U26.1 (GSO), U26.4 (VDD), U26.5 (GS1); also elsewhere on the board
CS_THERM: U25.P$24 (~CS); also elsewhere on the board
DRDY_THERM: U25.P$25 (~DRDY); also elsewhere on the board
GND: C272.2, C273.1, C274.2, C276.2, C277.2, C279.1, C280.2, C281.2, C283.1, R351.2, R353.1, R356.1, U25.P$2 (DGND), U25.P$10 (VREFCOM), U25.P$21 (AVSS), U26.2 (GND); also elsewhere on the board
unnamed: R355.1, R357.1, X68.2
unnamed: R356.2, R358.1, X68.1
unnamed: C272.1, C275.2, R352.2, U25.P$5 (REFP)
unnamed: C273.2, C275.1, R353.2, U25.P$6 (REFN)
unnamed: C280.1, U25.P$9 (VREFOUT)
unnamed: C282.1, C283.2, R360.1, U25.P$16 (AINN3)
unnamed: C281.1, C282.2, R359.1, U25.P$15 (AINP3)
unnamed: R351.1, R352.1, X68.5
unnamed: R359.2, U25.P$19 (IEXC1), X68.3
unnamed: R360.2, U25.P$20 (IEXC2), X68.4
RESET: R354.1, U25.P$4 (~RESET); also elsewhere on the board
SCLK_MASTER: U25.P$28 (SCLK); also elsewhere on the board
SDI_MASTER: U25.P$27 (DIN); also elsewhere on the board
SDO_MASTER: U25.P$26 (DOUT/~DRDY); also elsewhere on the board
START_THERM: U25.P$23 (START); also elsewhere on the board
THERM+: C277.1, C278.2, R357.2, U25.P$13 (AINP2)
THERM-: C278.1, C279.2, R358.2, U25.P$14 (AINN2)
TLOCAL: U25.P$18 (AINN1), U26.3 (OUT)

Schematic: alltogether_8.2_4w.sch, sheet 13, SSR

Parts:
C1, C2, C3: 0.1u; 0402-CAP
D167, D169: 250mA/100V; SOD-323
D168, D170: GREEN; LED-0603
JP2: JUMPER-PAD-2-NC_BY_PASTE; PAD-JUMPER-2-NC_BY_PASTE_YES_SILK
K21, K22: RT424005; RT2C/O
Q33, Q34: MOSFET-NCHANNELAO3404A; SOT23-3
R1, R2, R3, R4: 250; 0402-RES
R369, R370: 10k; 0402-RES
U34, U35: SN74LVC2G08DCUR; SOP50P310X90-8N
U36: SN74LVC2G04DCKR; SOT65P210X110-6N
U$11: PTSA0,5/42,5; PTSA0,5/8-2,5-Z
X73, X74, X75, X76: 1751264

Connections:
3.3VD: JP2.1; also elsewhere on the board
3.3VD_SSR: C1.1, C2.1, C3.1, JP2.2, U34.8 (VCC), U35.8 (VCC), U36.5 (VCC)
GND: C1.2, C2.2, C3.2, Q33.2 (S), Q34.2 (S), R1.2, R2.2, R3.2, R4.2, U34.4 (GND), U35.4 (GND), U36.2 (GND); also elsewhere on the board
LED_SSR_1: U34.3 (2Y), U$11.P$1
LED_SSR_2: U34.7 (1Y), U$11.P$3
LED_SSR_3: U35.3 (2Y), U$11.P$5
LED_SSR_4: U35.7 (1Y), U$11.P$7
unnamed: U35.1 (1A), U36.6 (1Y)
unnamed: U34.1 (1A), U36.4 (2Y)
unnamed: K21.11, X73.3, X73.4
unnamed: K21.21, X73.1, X73.2
unnamed: K21.14 (S), K21.22 (O), X74.3, X74.4
unnamed: K22.11, X75.3, X75.4
unnamed: K21.12 (O), K21.24 (S), X74.1, X74.2
unnamed: D167.A, K21.A2 (2), Q33.3 (D), R369.1
unnamed: D168.C, R369.2
unnamed: K22.21, X75.1, X75.2
unnamed: K22.14 (S), K22.22 (O), X76.3, X76.4
unnamed: K22.12 (O), K22.24 (S), X76.1, X76.2
unnamed: D169.A, K22.A2 (2), Q34.3 (D), R370.1
unnamed: D170.C, R370.2
unnamed: R1.1, U$11.P$2
unnamed: R2.1, U$11.P$4
unnamed: R3.1, U$11.P$6
unnamed: R4.1, U$11.P$8
RSW1: Q33.1 (G), U35.5 (2A), U36.1 (1A); also elsewhere on the board
RSW2: Q34.1 (G), U34.5 (2A), U36.3 (2A); also elsewhere on the board
SSR1: U35.2 (1B), U35.6 (2B); also elsewhere on the board
SSR2: U34.2 (1B), U34.6 (2B); also elsewhere on the board
VCC: D167.C, D168.A, D169.C, D170.A, K21.A1 (1), K22.A1 (1); also elsewhere on the board

Schematic: alltogether_8.2_4w.sch, sheet 14

Parts:
U$48, U$49, U$50, U$59, U$60, U$62, U$63, U$64: FIDUCIAL

Schematic: alltogether_8.2_4w.sch, sheet 15

Parts:
C5, C6: CAP0402-CAP; 0402-CAP
D1, D2, D21, D31, D32, D33: BAT20JFILM; SOD-323
IC8: INA118U; SO08
R37: RESISTOR0603-RES; 0603-RES
R65, R67: 1M; 0603-RES
R66: RESISTOR2512; R2512
U11: ADS1013IDGSR; SOP50P490X110-10N
X3: SPTAF1/2-3.5

Connections:
3.3VD: C5.1, D33.A, U11.8 (VDD); also elsewhere on the board
GND: C5.2, D32.C, IC8.5 (REF), R65.2, U11.1 (ADDR), U11.3 (GND), U11.5 (AIN1); also elsewhere on the board
unnamed: IC8.1 (RG), R37.2
unnamed: IC8.8 (RG), R37.1
unnamed: IC8.6 (OUT), R67.2
SCL: U11.10 (SCL); also elsewhere on the board
SDA: U11.9 (SDA); also elsewhere on the board
V+: D1.A, D2.C, IC8.3 (+IN), R66.1, X3.P$1, X3.P$2
V-: D21.C, D31.A, IC8.2 (-IN), R65.1, R66.2, X3.P$3, X3.P$4
VCC: C6.2, D1.C, D31.C, IC8.7 (V+); also elsewhere on the board
VDD: C6.1, D2.A, D21.A, IC8.4 (V-); also elsewhere on the board
VOUT: D32.A, D33.C, R67.1, U11.4 (AIN0)

Schematic: alltogether_8.2_4w.sch, sheet 16

Parts:
C23: 120n; 0402-CAP
C24, C25, C35, C36: 0.1u; 0402-CAP
C26, C27, C28, C29, C32: 0.1u; 0402
C30, C31: 1n; 0402
C33: 0.1u; 0603-CAP
C34: 22u; 0805
C37: 1n; 0402-CAP
D9, D10, D11, D12, D13, D14, D15: BAT20JFILM; SOD-323
D16, D17: TVSSMA; SMA-DIODE
IC2: OPA237U; SO08
IC3, IC4: INA118U; SO08
JP6, JP7, JP8: JUMPER-PAD-3-NC_BY_PASTE; PAD-JUMPER-3-NC_BY_PASTE_YES_SILK_FULL_BOX
K1: DSBT2-M-2D-DC1.5V; DS-BT
LED1: GREEN; CHIPLED_0603
Q1: MOSFET-NCHANNELAO3404A; SOT23-3
R29, R35, R40, R44, R46: 10k; 0402-RES
R30: 0.001; 2512
R31: 0; 0402-RES
R32: 125; 1206
R33, R36, R48, R49: 250; 0402-RES
R34, R47: 100k; 0402-RES
R38, R39: 47; 0402-RES
R41: RESISTOR1206; 1206
R42, R43: 125; 0402-RES
R45: 0; 0805
TP11, TP12, TP13, TP14: TESTPOINT0.1"; 1X01_ROUND
U$5, U$6, U$7: SPTAF1/2-3.5
U$8: MUX509; R-PDSO-G16

Connections:
A0: TP14.1, U$8.P$1 (A0); also elsewhere on the board
DAC1: R33.1, R47.2, TP13.1; also elsewhere on the board
FB1: JP8.3, R46.1
GND: C23.2, C24.2, C25.2, C26.2, C27.2, C28.1, C29.1, C30.1, C31.2, C35.1, C36.1, D16.C, D17.C, IC3.5 (REF), IC4.5 (REF), Q1.2 (S), R34.1, R40.1, R47.1, U$6.P$1, U$6.P$2, U$8.P$6 (S3A), U$8.P$11 (S3B), U$8.P$15 (GND); also elsewhere on the board
unnamed: D9.A, D10.C, K1.4, R30.2, R44.1, R49.1
unnamed: K1.13, R36.2
unnamed: IC3.1 (RG), R32.1
unnamed: IC3.8 (RG), R32.2
unnamed: C23.1, IC2.3 (+IN), R33.2
unnamed: D11.A, K1.16 (-), Q1.3 (D), R35.1
unnamed: LED1.C, R35.2
unnamed: C32.1, C33.1, IC2.2 (-IN), JP8.2, R40.2
unnamed: C32.2, C34.2, R29.2, R30.1, R45.2, R48.1, U$5.P$3, U$5.P$4
unnamed: IC3.6 (OUT), R38.1
unnamed: IC4.6 (OUT), JP6.3, R39.1, R46.2
unnamed: C33.2, C34.1, IC2.6 (OUT), R31.1, R45.1
unnamed: IC4.1 (RG), R41.1
unnamed: IC4.8 (RG), R41.2
unnamed: IC4.2 (-IN), JP6.2
unnamed: IC4.3 (+IN), JP7.2
unnamed: D14.C, D15.A, D17.A, JP6.1, R42.2
unnamed: R42.1, U$7.P$3, U$7.P$4
unnamed: D12.C, D13.A, D16.A, JP7.1, R43.2
unnamed: R43.1, U$7.P$1, U$7.P$2
unnamed: JP7.3, R44.2
unnamed: JP8.1, R29.1, R36.1
unnamed: R31.2, U$5.P$1, U$5.P$2
unnamed: IC3.2 (-IN), U$8.P$8 (DA)
unnamed: IC3.3 (+IN), U$8.P$9 (DB)
unnamed: C37.2, R49.2, U$8.P$10 (S4B)
unnamed: C37.1, R48.2, U$8.P$7 (S4A)
OUT1: K1.8 (S), K1.9 (S), U$6.P$3, U$6.P$4
SENSEI1: C31.1, R38.2, TP11.1; also elsewhere on the board
SENSEV1: C30.2, R39.2, TP12.1; also elsewhere on the board
SWITCH1: Q1.1 (G), R34.2; also elsewhere on the board
VCC: C25.1, C27.1, C29.2, C35.2, D9.C, D11.C, D13.C, D15.C, IC2.7 (V+), IC3.7 (V+), IC4.7 (V+), K1.1 (+), LED1.A, U$8.P$2 (EN), U$8.P$14 (V+), U$8.P$16 (A1); also elsewhere on the board
VDD: C24.1, C26.1, C28.2, C36.2, D10.A, D12.A, D14.A, IC2.4 (V-), IC3.4 (V-), IC4.4 (V-), U$8.P$3 (V-); also elsewhere on the board

Schematic: alltogether_8.2_4w.sch, sheet 17

Parts:
C38: 120n; 0402-CAP
C39, C40, C50, C51: 0.1u; 0402-CAP
C41, C42, C43, C44, C47: 0.1u; 0402
C45, C46: 1n; 0402
C48: 0.1u; 0603-CAP
C49: 22u; 0805
C52: 1n; 0402-CAP
D18, D19, D20, D22, D23, D24, D25: BAT20JFILM; SOD-323
D26, D27: TVSSMA; SMA-DIODE
IC5: OPA237U; SO08
IC6, IC7: INA118U; SO08
JP9, JP10, JP11: JUMPER-PAD-3-NC_BY_PASTE; PAD-JUMPER-3-NC_BY_PASTE_YES_SILK_FULL_BOX
K2: DSBT2-M-2D-DC1.5V; DS-BT
LED2: GREEN; CHIPLED_0603
Q2: MOSFET-NCHANNELAO3404A; SOT23-3
R50, R56, R60, R64, R69: 10k; 0402-RES
R51: 0.001; 2512
R52: 0; 0402-RES
R53: 125; 1206
R54, R57, R71, R72: 250; 0402-RES
R55, R70: 100k; 0402-RES
R58, R59: 47; 0402-RES
R61: RESISTOR1206; 1206
R62, R63: 125; 0402-RES
R68: 0; 0805
TP15, TP16, TP17, TP18: TESTPOINT0.1"; 1X01_ROUND
U$9, U$10, U$12: SPTAF1/2-3.5
U$14: MUX509; R-PDSO-G16

Connections:
A0: TP18.1, U$14.P$1 (A0); also elsewhere on the board
DAC2: R54.1, R70.2, TP17.1; also elsewhere on the board
FB2: JP11.3, R69.1
GND: C38.2, C39.2, C40.2, C41.2, C42.2, C43.1, C44.1, C45.1, C46.2, C50.1, C51.1, D26.C, D27.C, IC6.5 (REF), IC7.5 (REF), Q2.2 (S), R55.1, R60.1, R70.1, U$10.P$1, U$10.P$2, U$14.P$6 (S3A), U$14.P$11 (S3B), U$14.P$15 (GND); also elsewhere on the board
unnamed: D18.A, D19.C, K2.4, R51.2, R64.1, R72.1
unnamed: K2.13, R57.2
unnamed: IC6.1 (RG), R53.1
unnamed: IC6.8 (RG), R53.2
unnamed: C38.1, IC5.3 (+IN), R54.2
unnamed: D20.A, K2.16 (-), Q2.3 (D), R56.1
unnamed: LED2.C, R56.2
unnamed: C47.1, C48.1, IC5.2 (-IN), JP11.2, R60.2
unnamed: C47.2, C49.2, R50.2, R51.1, R68.2, R71.1, U$9.P$3, U$9.P$4
unnamed: IC6.6 (OUT), R58.1
unnamed: IC7.6 (OUT), JP9.3, R59.1, R69.2
unnamed: C48.2, C49.1, IC5.6 (OUT), R52.1, R68.1
unnamed: IC7.1 (RG), R61.1
unnamed: IC7.8 (RG), R61.2
unnamed: IC7.2 (-IN), JP9.2
unnamed: IC7.3 (+IN), JP10.2
unnamed: D24.C, D25.A, D27.A, JP9.1, R62.2
unnamed: R62.1, U$12.P$3, U$12.P$4
unnamed: D22.C, D23.A, D26.A, JP10.1, R63.2
unnamed: R63.1, U$12.P$1, U$12.P$2
unnamed: JP10.3, R64.2
unnamed: JP11.1, R50.1, R57.1
unnamed: R52.2, U$9.P$1, U$9.P$2
unnamed: IC6.2 (-IN), U$14.P$8 (DA)
unnamed: IC6.3 (+IN), U$14.P$9 (DB)
unnamed: C52.2, R72.2, U$14.P$10 (S4B)
unnamed: C52.1, R71.2, U$14.P$7 (S4A)
OUT2: K2.8 (S), K2.9 (S), U$10.P$3, U$10.P$4
SENSEI2: C46.1, R58.2, TP15.1; also elsewhere on the board
SENSEV2: C45.2, R59.2, TP16.1; also elsewhere on the board
SWITCH2: Q2.1 (G), R55.2; also elsewhere on the board
VCC: C40.1, C42.1, C44.2, C50.2, D18.C, D20.C, D23.C, D25.C, IC5.7 (V+), IC6.7 (V+), IC7.7 (V+), K2.1 (+), LED2.A, U$14.P$2 (EN), U$14.P$14 (V+), U$14.P$16 (A1); also elsewhere on the board
VDD: C39.1, C41.1, C43.2, C51.2, D19.A, D22.A, D24.A, IC5.4 (V-), IC6.4 (V-), IC7.4 (V-), U$14.P$3 (V-); also elsewhere on the board

Schematic: alltogether_8.2_4w.sch, sheet 18

Parts:
C68: 120n; 0402-CAP
C69, C70, C80, C81: 0.1u; 0402-CAP
C71, C72, C73, C74, C77: 0.1u; 0402
C75, C76: 1n; 0402
C78: 0.1u; 0603-CAP
C79: 22u; 0805
C82: 1n; 0402-CAP
D41, D42, D43, D44, D45, D46, D47: BAT20JFILM; SOD-323
D51, D52: TVSSMA; SMA-DIODE
IC12: OPA237U; SO08
IC13, IC14: INA118U; SO08
JP15, JP16, JP17: JUMPER-PAD-3-NC_BY_PASTE; PAD-JUMPER-3-NC_BY_PASTE_YES_SILK_FULL_BOX
K4: DSBT2-M-2D-DC1.5V; DS-BT
LED4: GREEN; CHIPLED_0603
Q4: MOSFET-NCHANNELAO3404A; SOT23-3
R95, R101, R105, R109, R111: 10k; 0402-RES
R96: 0.001; 2512
R97: 0; 0402-RES
R98: 125; 1206
R99, R102, R113, R114: 250; 0402-RES
R100, R112: 100k; 0402-RES
R103, R104: 47; 0402-RES
R106: RESISTOR1206; 1206
R107, R108: 125; 0402-RES
R110: 0; 0805
TP23, TP24, TP25, TP26: TESTPOINT0.1"; 1X01_ROUND
U$20, U$21, U$22: SPTAF1/2-3.5
U$23: MUX509; R-PDSO-G16

Connections:
A0: TP26.1, U$23.P$1 (A0); also elsewhere on the board
DAC3: R99.1, R112.2, TP25.1; also elsewhere on the board
FB3: JP17.3, R111.1
GND: C68.2, C69.2, C70.2, C71.2, C72.2, C73.1, C74.1, C75.1, C76.2, C80.1, C81.1, D51.C, D52.C, IC13.5 (REF), IC14.5 (REF), Q4.2 (S), R100.1, R105.1, R112.1, U$21.P$1, U$21.P$2, U$23.P$6 (S3A), U$23.P$11 (S3B), U$23.P$15 (GND); also elsewhere on the board
unnamed: D41.A, D42.C, K4.4, R96.2, R109.1, R114.1
unnamed: K4.13, R102.2
unnamed: IC13.1 (RG), R98.1
unnamed: IC13.8 (RG), R98.2
unnamed: C68.1, IC12.3 (+IN), R99.2
unnamed: D43.A, K4.16 (-), Q4.3 (D), R101.1
unnamed: LED4.C, R101.2
unnamed: C77.1, C78.1, IC12.2 (-IN), JP17.2, R105.2
unnamed: C77.2, C79.2, R95.2, R96.1, R110.2, R113.1, U$20.P$3, U$20.P$4
unnamed: IC13.6 (OUT), R103.1
unnamed: IC14.6 (OUT), JP15.3, R104.1, R111.2
unnamed: C78.2, C79.1, IC12.6 (OUT), R97.1, R110.1
unnamed: IC14.1 (RG), R106.1
unnamed: IC14.8 (RG), R106.2
unnamed: IC14.2 (-IN), JP15.2
unnamed: IC14.3 (+IN), JP16.2
unnamed: D46.C, D47.A, D52.A, JP15.1, R107.2
unnamed: R107.1, U$22.P$3, U$22.P$4
unnamed: D44.C, D45.A, D51.A, JP16.1, R108.2
unnamed: R108.1, U$22.P$1, U$22.P$2
unnamed: JP16.3, R109.2
unnamed: JP17.1, R95.1, R102.1
unnamed: R97.2, U$20.P$1, U$20.P$2
unnamed: IC13.2 (-IN), U$23.P$8 (DA)
unnamed: IC13.3 (+IN), U$23.P$9 (DB)
unnamed: C82.2, R114.2, U$23.P$10 (S4B)
unnamed: C82.1, R113.2, U$23.P$7 (S4A)
OUT3: K4.8 (S), K4.9 (S), U$21.P$3, U$21.P$4
SENSEI3: C76.1, R103.2, TP23.1; also elsewhere on the board
SENSEV3: C75.2, R104.2, TP24.1; also elsewhere on the board
SWITCH3: Q4.1 (G), R100.2; also elsewhere on the board
VCC: C70.1, C72.1, C74.2, C80.2, D41.C, D43.C, D45.C, D47.C, IC12.7 (V+), IC13.7 (V+), IC14.7 (V+), K4.1 (+), LED4.A, U$23.P$2 (EN), U$23.P$14 (V+), U$23.P$16 (A1); also elsewhere on the board
VDD: C69.1, C71.1, C73.2, C81.2, D42.A, D44.A, D46.A, IC12.4 (V-), IC13.4 (V-), IC14.4 (V-), U$23.P$3 (V-); also elsewhere on the board

Schematic: alltogether_8.2_4w.sch, sheet 19

Parts:
C98: 120n; 0402-CAP
C99, C100, C110, C111: 0.1u; 0402-CAP
C101, C102, C103, C104, C107: 0.1u; 0402
C105, C106: 1n; 0402
C108: 0.1u; 0603-CAP
C109: 22u; 0805
C112: 1n; 0402-CAP
D62, D63, D64, D65, D66, D67, D68: BAT20JFILM; SOD-323
D69, D70: TVSSMA; SMA-DIODE
IC18: OPA237U; SO08
IC19, IC20: INA118U; SO08
JP21, JP22, JP23: JUMPER-PAD-3-NC_BY_PASTE; PAD-JUMPER-3-NC_BY_PASTE_YES_SILK_FULL_BOX
K6: DSBT2-M-2D-DC1.5V; DS-BT
LED6: GREEN; CHIPLED_0603
Q6: MOSFET-NCHANNELAO3404A; SOT23-3
R135, R141, R145, R149, R151: 10k; 0402-RES
R136: 0.001; 2512
R137: 0; 0402-RES
R138: 125; 1206
R139, R142, R153, R154: 250; 0402-RES
R140, R152: 100k; 0402-RES
R143, R144: 47; 0402-RES
R146: RESISTOR1206; 1206
R147, R148: 125; 0402-RES
R150: 0; 0805
TP31, TP32, TP33, TP34: TESTPOINT0.1"; 1X01_ROUND
U$28, U$29, U$30: SPTAF1/2-3.5
U$31: MUX509; R-PDSO-G16

Connections:
A0: TP34.1, U$31.P$1 (A0); also elsewhere on the board
DAC4: R139.1, R152.2, TP33.1; also elsewhere on the board
FB4: JP23.3, R151.1
GND: C98.2, C99.2, C100.2, C101.2, C102.2, C103.1, C104.1, C105.1, C106.2, C110.1, C111.1, D69.C, D70.C, IC19.5 (REF), IC20.5 (REF), Q6.2 (S), R140.1, R145.1, R152.1, U$29.P$1, U$29.P$2, U$31.P$6 (S3A), U$31.P$11 (S3B), U$31.P$15 (GND); also elsewhere on the board
unnamed: D62.A, D63.C, K6.4, R136.2, R149.1, R154.1
unnamed: K6.13, R142.2
unnamed: IC19.1 (RG), R138.1
unnamed: IC19.8 (RG), R138.2
unnamed: C98.1, IC18.3 (+IN), R139.2
unnamed: D64.A, K6.16 (-), Q6.3 (D), R141.1
unnamed: LED6.C, R141.2
unnamed: C107.1, C108.1, IC18.2 (-IN), JP23.2, R145.2
unnamed: C107.2, C109.2, R135.2, R136.1, R150.2, R153.1, U$28.P$3, U$28.P$4
unnamed: IC19.6 (OUT), R143.1
unnamed: IC20.6 (OUT), JP21.3, R144.1, R151.2
unnamed: C108.2, C109.1, IC18.6 (OUT), R137.1, R150.1
unnamed: IC20.1 (RG), R146.1
unnamed: IC20.8 (RG), R146.2
unnamed: IC20.2 (-IN), JP21.2
unnamed: IC20.3 (+IN), JP22.2
unnamed: D67.C, D68.A, D70.A, JP21.1, R147.2
unnamed: R147.1, U$30.P$3, U$30.P$4
unnamed: D65.C, D66.A, D69.A, JP22.1, R148.2
unnamed: R148.1, U$30.P$1, U$30.P$2
unnamed: JP22.3, R149.2
unnamed: JP23.1, R135.1, R142.1
unnamed: R137.2, U$28.P$1, U$28.P$2
unnamed: IC19.2 (-IN), U$31.P$8 (DA)
unnamed: IC19.3 (+IN), U$31.P$9 (DB)
unnamed: C112.2, R154.2, U$31.P$10 (S4B)
unnamed: C112.1, R153.2, U$31.P$7 (S4A)
OUT4: K6.8 (S), K6.9 (S), U$29.P$3, U$29.P$4
SENSEI4: C106.1, R143.2, TP31.1; also elsewhere on the board
SENSEV4: C105.2, R144.2, TP32.1; also elsewhere on the board
SWITCH4: Q6.1 (G), R140.2; also elsewhere on the board
VCC: C100.1, C102.1, C104.2, C110.2, D62.C, D64.C, D66.C, D68.C, IC18.7 (V+), IC19.7 (V+), IC20.7 (V+), K6.1 (+), LED6.A, U$31.P$2 (EN), U$31.P$14 (V+), U$31.P$16 (A1); also elsewhere on the board
VDD: C99.1, C101.1, C103.2, C111.2, D63.A, D65.A, D67.A, IC18.4 (V-), IC19.4 (V-), IC20.4 (V-), U$31.P$3 (V-); also elsewhere on the board

Schematic: alltogether_8.2_4w.sch, sheet 20

Parts:
C128: 120n; 0402-CAP
C129, C130, C140, C141: 0.1u; 0402-CAP
C131, C132, C133, C134, C137: 0.1u; 0402
C135, C136: 1n; 0402
C138: 0.1u; 0603-CAP
C139: 22u; 0805
C142: 1n; 0402-CAP
D80, D81, D82, D83, D84, D85, D86: BAT20JFILM; SOD-323
D87, D88: TVSSMA; SMA-DIODE
IC24: OPA237U; SO08
IC25, IC26: INA118U; SO08
JP27, JP28, JP29: JUMPER-PAD-3-NC_BY_PASTE; PAD-JUMPER-3-NC_BY_PASTE_YES_SILK_FULL_BOX
K8: DSBT2-M-2D-DC1.5V; DS-BT
LED8: GREEN; CHIPLED_0603
Q8: MOSFET-NCHANNELAO3404A; SOT23-3
R175, R181, R185, R189, R191: 10k; 0402-RES
R176: 0.001; 2512
R177: 0; 0402-RES
R178: 125; 1206
R179, R182, R193, R194: 250; 0402-RES
R180, R192: 100k; 0402-RES
R183, R184: 47; 0402-RES
R186: RESISTOR1206; 1206
R187, R188: 125; 0402-RES
R190: 0; 0805
TP39, TP40, TP41, TP42: TESTPOINT0.1"; 1X01_ROUND
U$37, U$39, U$40: SPTAF1/2-3.5
U$41: MUX509; R-PDSO-G16

Connections:
A0: TP42.1, U$41.P$1 (A0); also elsewhere on the board
DAC5: R179.1, R192.2, TP41.1; also elsewhere on the board
FB5: JP29.3, R191.1
GND: C128.2, C129.2, C130.2, C131.2, C132.2, C133.1, C134.1, C135.1, C136.2, C140.1, C141.1, D87.C, D88.C, IC25.5 (REF), IC26.5 (REF), Q8.2 (S), R180.1, R185.1, R192.1, U$39.P$1, U$39.P$2, U$41.P$6 (S3A), U$41.P$11 (S3B), U$41.P$15 (GND); also elsewhere on the board
unnamed: D80.A, D81.C, K8.4, R176.2, R189.1, R194.1
unnamed: K8.13, R182.2
unnamed: IC25.1 (RG), R178.1
unnamed: IC25.8 (RG), R178.2
unnamed: C128.1, IC24.3 (+IN), R179.2
unnamed: D82.A, K8.16 (-), Q8.3 (D), R181.1
unnamed: LED8.C, R181.2
unnamed: C137.1, C138.1, IC24.2 (-IN), JP29.2, R185.2
unnamed: C137.2, C139.2, R175.2, R176.1, R190.2, R193.1, U$37.P$3, U$37.P$4
unnamed: IC25.6 (OUT), R183.1
unnamed: IC26.6 (OUT), JP27.3, R184.1, R191.2
unnamed: C138.2, C139.1, IC24.6 (OUT), R177.1, R190.1
unnamed: IC26.1 (RG), R186.1
unnamed: IC26.8 (RG), R186.2
unnamed: IC26.2 (-IN), JP27.2
unnamed: IC26.3 (+IN), JP28.2
unnamed: D85.C, D86.A, D88.A, JP27.1, R187.2
unnamed: R187.1, U$40.P$3, U$40.P$4
unnamed: D83.C, D84.A, D87.A, JP28.1, R188.2
unnamed: R188.1, U$40.P$1, U$40.P$2
unnamed: JP28.3, R189.2
unnamed: JP29.1, R175.1, R182.1
unnamed: R177.2, U$37.P$1, U$37.P$2
unnamed: IC25.2 (-IN), U$41.P$8 (DA)
unnamed: IC25.3 (+IN), U$41.P$9 (DB)
unnamed: C142.2, R194.2, U$41.P$10 (S4B)
unnamed: C142.1, R193.2, U$41.P$7 (S4A)
OUT5: K8.8 (S), K8.9 (S), U$39.P$3, U$39.P$4
SENSEI5: C136.1, R183.2, TP39.1; also elsewhere on the board
SENSEV5: C135.2, R184.2, TP40.1; also elsewhere on the board
SWITCH5: Q8.1 (G), R180.2; also elsewhere on the board
VCC: C130.1, C132.1, C134.2, C140.2, D80.C, D82.C, D84.C, D86.C, IC24.7 (V+), IC25.7 (V+), IC26.7 (V+), K8.1 (+), LED8.A, U$41.P$2 (EN), U$41.P$14 (V+), U$41.P$16 (A1); also elsewhere on the board
VDD: C129.1, C131.1, C133.2, C141.2, D81.A, D83.A, D85.A, IC24.4 (V-), IC25.4 (V-), IC26.4 (V-), U$41.P$3 (V-); also elsewhere on the board

Schematic: alltogether_8.2_4w.sch, sheet 21

Parts:
C158: 120n; 0402-CAP
C159, C160, C291, C292: 0.1u; 0402-CAP
C244, C248, C284, C285, C288: 0.1u; 0402
C286, C287: 1n; 0402
C289: 0.1u; 0603-CAP
C290: 22u; 0805
C293: 1n; 0402-CAP
D98, D99, D100, D101, D102, D103, D104: BAT20JFILM; SOD-323
D105, D106: TVSSMA; SMA-DIODE
IC30: OPA237U; SO08
IC31, IC32: INA118U; SO08
JP33, JP34, JP35: JUMPER-PAD-3-NC_BY_PASTE; PAD-JUMPER-3-NC_BY_PASTE_YES_SILK_FULL_BOX
K10: DSBT2-M-2D-DC1.5V; DS-BT
LED10: GREEN; CHIPLED_0603
Q10: MOSFET-NCHANNELAO3404A; SOT23-3
R215, R221, R225, R229, R231: 10k; 0402-RES
R216: 0.001; 2512
R217: 0; 0402-RES
R218: 125; 1206
R219, R222, R233, R234: 250; 0402-RES
R220, R232: 100k; 0402-RES
R223, R224: 47; 0402-RES
R226: RESISTOR1206; 1206
R227, R228: 125; 0402-RES
R230: 0; 0805
TP47, TP48, TP49, TP50: TESTPOINT0.1"; 1X01_ROUND
U$46, U$47, U$51: SPTAF1/2-3.5
U$52: MUX509; R-PDSO-G16

Connections:
A0: TP50.1, U$52.P$1 (A0); also elsewhere on the board
DAC6: R219.1, R232.2, TP49.1; also elsewhere on the board
FB6: JP35.3, R231.1
GND: C158.2, C159.2, C160.2, C244.2, C248.2, C284.1, C285.1, C286.1, C287.2, C291.1, C292.1, D105.C, D106.C, IC31.5 (REF), IC32.5 (REF), Q10.2 (S), R220.1, R225.1, R232.1, U$47.P$1, U$47.P$2, U$52.P$6 (S3A), U$52.P$11 (S3B), U$52.P$15 (GND); also elsewhere on the board
unnamed: D98.A, D99.C, K10.4, R216.2, R229.1, R234.1
unnamed: K10.13, R222.2
unnamed: IC31.1 (RG), R218.1
unnamed: IC31.8 (RG), R218.2
unnamed: C158.1, IC30.3 (+IN), R219.2
unnamed: D100.A, K10.16 (-), Q10.3 (D), R221.1
unnamed: LED10.C, R221.2
unnamed: C288.1, C289.1, IC30.2 (-IN), JP35.2, R225.2
unnamed: C288.2, C290.2, R215.2, R216.1, R230.2, R233.1, U$46.P$3, U$46.P$4
unnamed: IC31.6 (OUT), R223.1
unnamed: IC32.6 (OUT), JP33.3, R224.1, R231.2
unnamed: C289.2, C290.1, IC30.6 (OUT), R217.1, R230.1
unnamed: IC32.1 (RG), R226.1
unnamed: IC32.8 (RG), R226.2
unnamed: IC32.2 (-IN), JP33.2
unnamed: IC32.3 (+IN), JP34.2
unnamed: D103.C, D104.A, D106.A, JP33.1, R227.2
unnamed: R227.1, U$51.P$3, U$51.P$4
unnamed: D101.C, D102.A, D105.A, JP34.1, R228.2
unnamed: R228.1, U$51.P$1, U$51.P$2
unnamed: JP34.3, R229.2
unnamed: JP35.1, R215.1, R222.1
unnamed: R217.2, U$46.P$1, U$46.P$2
unnamed: IC31.2 (-IN), U$52.P$8 (DA)
unnamed: IC31.3 (+IN), U$52.P$9 (DB)
unnamed: C293.2, R234.2, U$52.P$10 (S4B)
unnamed: C293.1, R233.2, U$52.P$7 (S4A)
OUT6: K10.8 (S), K10.9 (S), U$47.P$3, U$47.P$4
SENSEI6: C287.1, R223.2, TP47.1; also elsewhere on the board
SENSEV6: C286.2, R224.2, TP48.1; also elsewhere on the board
SWITCH6: Q10.1 (G), R220.2; also elsewhere on the board
VCC: C160.1, C248.1, C285.2, C291.2, D98.C, D100.C, D102.C, D104.C, IC30.7 (V+), IC31.7 (V+), IC32.7 (V+), K10.1 (+), LED10.A, U$52.P$2 (EN), U$52.P$14 (V+), U$52.P$16 (A1); also elsewhere on the board
VDD: C159.1, C244.1, C284.2, C292.2, D99.A, D101.A, D103.A, IC30.4 (V-), IC31.4 (V-), IC32.4 (V-), U$52.P$3 (V-); also elsewhere on the board

Schematic: alltogether_8.2_4w.sch, sheet 22

Parts:
C314: 120n; 0402-CAP
C315, C316, C326, C327: 0.1u; 0402-CAP
C317, C318, C319, C320, C323: 0.1u; 0402
C321, C322: 1n; 0402
C324: 0.1u; 0603-CAP
C325: 22u; 0805
C328: 1n; 0402-CAP
D116, D117, D118, D119, D120, D121, D122: BAT20JFILM; SOD-323
D123, D124: TVSSMA; SMA-DIODE
IC36: OPA237U; SO08
IC37, IC38: INA118U; SO08
JP39, JP40, JP41: JUMPER-PAD-3-NC_BY_PASTE; PAD-JUMPER-3-NC_BY_PASTE_YES_SILK_FULL_BOX
K12: DSBT2-M-2D-DC1.5V; DS-BT
LED12: GREEN; CHIPLED_0603
Q12: MOSFET-NCHANNELAO3404A; SOT23-3
R278, R284, R314, R336, R338: 10k; 0402-RES
R279: 0.001; 2512
R280: 0; 0402-RES
R281: 125; 1206
R282, R285, R340, R361: 250; 0402-RES
R283, R339: 100k; 0402-RES
R301, R312: 47; 0402-RES
R333: RESISTOR1206; 1206
R334, R335: 125; 0402-RES
R337: 0; 0805
TP55, TP56, TP57, TP58: TESTPOINT0.1"; 1X01_ROUND
U$57, U$58, U$61: SPTAF1/2-3.5
U$65: MUX509; R-PDSO-G16

Connections:
A0: TP58.1, U$65.P$1 (A0); also elsewhere on the board
DAC7: R282.1, R339.2, TP57.1; also elsewhere on the board
FB7: JP41.3, R338.1
GND: C314.2, C315.2, C316.2, C317.2, C318.2, C319.1, C320.1, C321.1, C322.2, C326.1, C327.1, D123.C, D124.C, IC37.5 (REF), IC38.5 (REF), Q12.2 (S), R283.1, R314.1, R339.1, U$58.P$1, U$58.P$2, U$65.P$6 (S3A), U$65.P$11 (S3B), U$65.P$15 (GND); also elsewhere on the board
unnamed: D116.A, D117.C, K12.4, R279.2, R336.1, R361.1
unnamed: K12.13, R285.2
unnamed: IC37.1 (RG), R281.1
unnamed: IC37.8 (RG), R281.2
unnamed: C314.1, IC36.3 (+IN), R282.2
unnamed: D118.A, K12.16 (-), Q12.3 (D), R284.1
unnamed: LED12.C, R284.2
unnamed: C323.1, C324.1, IC36.2 (-IN), JP41.2, R314.2
unnamed: C323.2, C325.2, R278.2, R279.1, R337.2, R340.1, U$57.P$3, U$57.P$4
unnamed: IC37.6 (OUT), R301.1
unnamed: IC38.6 (OUT), JP39.3, R312.1, R338.2
unnamed: C324.2, C325.1, IC36.6 (OUT), R280.1, R337.1
unnamed: IC38.1 (RG), R333.1
unnamed: IC38.8 (RG), R333.2
unnamed: IC38.2 (-IN), JP39.2
unnamed: IC38.3 (+IN), JP40.2
unnamed: D121.C, D122.A, D124.A, JP39.1, R334.2
unnamed: R334.1, U$61.P$3, U$61.P$4
unnamed: D119.C, D120.A, D123.A, JP40.1, R335.2
unnamed: R335.1, U$61.P$1, U$61.P$2
unnamed: JP40.3, R336.2
unnamed: JP41.1, R278.1, R285.1
unnamed: R280.2, U$57.P$1, U$57.P$2
unnamed: IC37.2 (-IN), U$65.P$8 (DA)
unnamed: IC37.3 (+IN), U$65.P$9 (DB)
unnamed: C328.2, R361.2, U$65.P$10 (S4B)
unnamed: C328.1, R340.2, U$65.P$7 (S4A)
OUT7: K12.8 (S), K12.9 (S), U$58.P$3, U$58.P$4
SENSEI7: C322.1, R301.2, TP55.1; also elsewhere on the board
SENSEV7: C321.2, R312.2, TP56.1; also elsewhere on the board
SWITCH7: Q12.1 (G), R283.2; also elsewhere on the board
VCC: C316.1, C318.1, C320.2, C326.2, D116.C, D118.C, D120.C, D122.C, IC36.7 (V+), IC37.7 (V+), IC38.7 (V+), K12.1 (+), LED12.A, U$65.P$2 (EN), U$65.P$14 (V+), U$65.P$16 (A1); also elsewhere on the board
VDD: C315.1, C317.1, C319.2, C327.2, D117.A, D119.A, D121.A, IC36.4 (V-), IC37.4 (V-), IC38.4 (V-), U$65.P$3 (V-); also elsewhere on the board

Schematic: alltogether_8.2_4w.sch, sheet 23

Parts:
C344: 120n; 0402-CAP
C345, C346, C356, C357: 0.1u; 0402-CAP
C347, C348, C349, C350, C353: 0.1u; 0402
C351, C352: 1n; 0402
C354: 0.1u; 0603-CAP
C355: 22u; 0805
C358: 1n; 0402-CAP
D134, D135, D136, D137, D138, D139, D140: BAT20JFILM; SOD-323
D141, D142: TVSSMA; SMA-DIODE
IC44: OPA237U; SO08
IC45, IC46: INA118U; SO08
JP45, JP46, JP47: JUMPER-PAD-3-NC_BY_PASTE; PAD-JUMPER-3-NC_BY_PASTE_YES_SILK_FULL_BOX
K14: DSBT2-M-2D-DC1.5V; DS-BT
LED15: GREEN; CHIPLED_0603
Q15: MOSFET-NCHANNELAO3404A; SOT23-3
R391, R397, R401, R405, R407: 10k; 0402-RES
R392: 0.001; 2512
R393: 0; 0402-RES
R394: 125; 1206
R395, R398, R409, R410: 250; 0402-RES
R396, R408: 100k; 0402-RES
R399, R400: 47; 0402-RES
R402: RESISTOR1206; 1206
R403, R404: 125; 0402-RES
R406: 0; 0805
TP63, TP64, TP65, TP66: TESTPOINT0.1"; 1X01_ROUND
U$71, U$72, U$73: SPTAF1/2-3.5
U$74: MUX509; R-PDSO-G16

Connections:
A0: TP66.1, U$74.P$1 (A0); also elsewhere on the board
DAC8: R395.1, R408.2, TP65.1; also elsewhere on the board
FB8: JP47.3, R407.1
GND: C344.2, C345.2, C346.2, C347.2, C348.2, C349.1, C350.1, C351.1, C352.2, C356.1, C357.1, D141.C, D142.C, IC45.5 (REF), IC46.5 (REF), Q15.2 (S), R396.1, R401.1, R408.1, U$72.P$1, U$72.P$2, U$74.P$6 (S3A), U$74.P$11 (S3B), U$74.P$15 (GND); also elsewhere on the board
unnamed: D134.A, D135.C, K14.4, R392.2, R405.1, R410.1
unnamed: K14.13, R398.2
unnamed: IC45.1 (RG), R394.1
unnamed: IC45.8 (RG), R394.2
unnamed: C344.1, IC44.3 (+IN), R395.2
unnamed: D136.A, K14.16 (-), Q15.3 (D), R397.1
unnamed: LED15.C, R397.2
unnamed: C353.1, C354.1, IC44.2 (-IN), JP47.2, R401.2
unnamed: C353.2, C355.2, R391.2, R392.1, R406.2, R409.1, U$71.P$3, U$71.P$4
unnamed: IC45.6 (OUT), R399.1
unnamed: IC46.6 (OUT), JP45.3, R400.1, R407.2
unnamed: C354.2, C355.1, IC44.6 (OUT), R393.1, R406.1
unnamed: IC46.1 (RG), R402.1
unnamed: IC46.8 (RG), R402.2
unnamed: IC46.2 (-IN), JP45.2
unnamed: IC46.3 (+IN), JP46.2
unnamed: D139.C, D140.A, D142.A, JP45.1, R403.2
unnamed: R403.1, U$73.P$3, U$73.P$4
unnamed: D137.C, D138.A, D141.A, JP46.1, R404.2
unnamed: R404.1, U$73.P$1, U$73.P$2
unnamed: JP46.3, R405.2
unnamed: JP47.1, R391.1, R398.1
unnamed: R393.2, U$71.P$1, U$71.P$2
unnamed: IC45.2 (-IN), U$74.P$8 (DA)
unnamed: IC45.3 (+IN), U$74.P$9 (DB)
unnamed: C358.2, R410.2, U$74.P$10 (S4B)
unnamed: C358.1, R409.2, U$74.P$7 (S4A)
OUT8: K14.8 (S), K14.9 (S), U$72.P$3, U$72.P$4
SENSEI8: C352.1, R399.2, TP63.1; also elsewhere on the board
SENSEV8: C351.2, R400.2, TP64.1; also elsewhere on the board
SWITCH8: Q15.1 (G), R396.2; also elsewhere on the board
VCC: C346.1, C348.1, C350.2, C356.2, D134.C, D136.C, D138.C, D140.C, IC44.7 (V+), IC45.7 (V+), IC46.7 (V+), K14.1 (+), LED15.A, U$74.P$2 (EN), U$74.P$14 (V+), U$74.P$16 (A1); also elsewhere on the board
VDD: C345.1, C347.1, C349.2, C357.2, D135.A, D137.A, D139.A, IC44.4 (V-), IC45.4 (V-), IC46.4 (V-), U$74.P$3 (V-); also elsewhere on the board

Schematic: alltogether_8.2_4w.sch, sheet 24

Parts:
C374: 120n; 0402-CAP
C375, C376, C386, C387: 0.1u; 0402-CAP
C377, C378, C379, C380, C383: 0.1u; 0402
C381, C382: 1n; 0402
C384: 0.1u; 0603-CAP
C385: 22u; 0805
C388: 1n; 0402-CAP
D180, D181, D182, D183, D184, D185, D186: BAT20JFILM; SOD-323
D187, D188: TVSSMA; SMA-DIODE
IC53: OPA237U; SO08
IC54, IC55: INA118U; SO08
JP51, JP52, JP53: JUMPER-PAD-3-NC_BY_PASTE; PAD-JUMPER-3-NC_BY_PASTE_YES_SILK_FULL_BOX
K23: DSBT2-M-2D-DC1.5V; DS-BT
LED17: GREEN; CHIPLED_0603
Q22: MOSFET-NCHANNELAO3404A; SOT23-3
R431, R437, R441, R445, R447: 10k; 0402-RES
R432: 0.001; 2512
R433: 0; 0402-RES
R434: 125; 1206
R435, R438, R449, R450: 250; 0402-RES
R436, R448: 100k; 0402-RES
R439, R440: 47; 0402-RES
R442: RESISTOR1206; 1206
R443, R444: 125; 0402-RES
R446: 0; 0805
TP71, TP72, TP73, TP74: TESTPOINT0.1"; 1X01_ROUND
U$79, U$80, U$81: SPTAF1/2-3.5
U$82: MUX509; R-PDSO-G16

Connections:
A0: TP74.1, U$82.P$1 (A0); also elsewhere on the board
DAC9: R435.1, R448.2, TP73.1; also elsewhere on the board
FB9: JP53.3, R447.1
GND: C374.2, C375.2, C376.2, C377.2, C378.2, C379.1, C380.1, C381.1, C382.2, C386.1, C387.1, D187.C, D188.C, IC54.5 (REF), IC55.5 (REF), Q22.2 (S), R436.1, R441.1, R448.1, U$80.P$1, U$80.P$2, U$82.P$6 (S3A), U$82.P$11 (S3B), U$82.P$15 (GND); also elsewhere on the board
unnamed: D180.A, D181.C, K23.4, R432.2, R445.1, R450.1
unnamed: K23.13, R438.2
unnamed: IC54.1 (RG), R434.1
unnamed: IC54.8 (RG), R434.2
unnamed: C374.1, IC53.3 (+IN), R435.2
unnamed: D182.A, K23.16 (-), Q22.3 (D), R437.1
unnamed: LED17.C, R437.2
unnamed: C383.1, C384.1, IC53.2 (-IN), JP53.2, R441.2
unnamed: C383.2, C385.2, R431.2, R432.1, R446.2, R449.1, U$79.P$3, U$79.P$4
unnamed: IC54.6 (OUT), R439.1
unnamed: IC55.6 (OUT), JP51.3, R440.1, R447.2
unnamed: C384.2, C385.1, IC53.6 (OUT), R433.1, R446.1
unnamed: IC55.1 (RG), R442.1
unnamed: IC55.8 (RG), R442.2
unnamed: IC55.2 (-IN), JP51.2
unnamed: IC55.3 (+IN), JP52.2
unnamed: D185.C, D186.A, D188.A, JP51.1, R443.2
unnamed: R443.1, U$81.P$3, U$81.P$4
unnamed: D183.C, D184.A, D187.A, JP52.1, R444.2
unnamed: R444.1, U$81.P$1, U$81.P$2
unnamed: JP52.3, R445.2
unnamed: JP53.1, R431.1, R438.1
unnamed: R433.2, U$79.P$1, U$79.P$2
unnamed: IC54.2 (-IN), U$82.P$8 (DA)
unnamed: IC54.3 (+IN), U$82.P$9 (DB)
unnamed: C388.2, R450.2, U$82.P$10 (S4B)
unnamed: C388.1, R449.2, U$82.P$7 (S4A)
OUT9: K23.8 (S), K23.9 (S), U$80.P$3, U$80.P$4
SENSEI9: C382.1, R439.2, TP71.1; also elsewhere on the board
SENSEV9: C381.2, R440.2, TP72.1; also elsewhere on the board
SWITCH9: Q22.1 (G), R436.2; also elsewhere on the board
VCC: C376.1, C378.1, C380.2, C386.2, D180.C, D182.C, D184.C, D186.C, IC53.7 (V+), IC54.7 (V+), IC55.7 (V+), K23.1 (+), LED17.A, U$82.P$2 (EN), U$82.P$14 (V+), U$82.P$16 (A1); also elsewhere on the board
VDD: C375.1, C377.1, C379.2, C387.2, D181.A, D183.A, D185.A, IC53.4 (V-), IC54.4 (V-), IC55.4 (V-), U$82.P$3 (V-); also elsewhere on the board

Schematic: alltogether_8.2_4w.sch, sheet 25

Parts:
C404: 120n; 0402-CAP
C405, C406, C416, C417: 0.1u; 0402-CAP
C407, C408, C409, C410, C413: 0.1u; 0402
C411, C412: 1n; 0402
C414: 0.1u; 0603-CAP
C415: 22u; 0805
C418: 1n; 0402-CAP
D198, D199, D200, D201, D202, D203, D204: BAT20JFILM; SOD-323
D205, D206: TVSSMA; SMA-DIODE
IC59: OPA237U; SO08
IC60, IC61: INA118U; SO08
JP57, JP58, JP59: JUMPER-PAD-3-NC_BY_PASTE; PAD-JUMPER-3-NC_BY_PASTE_YES_SILK_FULL_BOX
K25: DSBT2-M-2D-DC1.5V; DS-BT
LED19: GREEN; CHIPLED_0603
Q36: MOSFET-NCHANNELAO3404A; SOT23-3
R472, R478, R482, R486, R488: 10k; 0402-RES
R473: 0.001; 2512
R474: 0; 0402-RES
R475: 125; 1206
R476, R479, R490, R491: 250; 0402-RES
R477, R489: 100k; 0402-RES
R480, R481: 47; 0402-RES
R483: RESISTOR1206; 1206
R484, R485: 125; 0402-RES
R487: 0; 0805
TP79, TP80, TP81, TP82: TESTPOINT0.1"; 1X01_ROUND
U$87, U$88, U$89: SPTAF1/2-3.5
U$90: MUX509; R-PDSO-G16

Connections:
A0: TP82.1, U$90.P$1 (A0); also elsewhere on the board
DAC10: R476.1, R489.2, TP81.1; also elsewhere on the board
FB10: JP59.3, R488.1
GND: C404.2, C405.2, C406.2, C407.2, C408.2, C409.1, C410.1, C411.1, C412.2, C416.1, C417.1, D205.C, D206.C, IC60.5 (REF), IC61.5 (REF), Q36.2 (S), R477.1, R482.1, R489.1, U$88.P$1, U$88.P$2, U$90.P$6 (S3A), U$90.P$11 (S3B), U$90.P$15 (GND); also elsewhere on the board
unnamed: D198.A, D199.C, K25.4, R473.2, R486.1, R491.1
unnamed: K25.13, R479.2
unnamed: IC60.1 (RG), R475.1
unnamed: IC60.8 (RG), R475.2
unnamed: C404.1, IC59.3 (+IN), R476.2
unnamed: D200.A, K25.16 (-), Q36.3 (D), R478.1
unnamed: LED19.C, R478.2
unnamed: C413.1, C414.1, IC59.2 (-IN), JP59.2, R482.2
unnamed: C413.2, C415.2, R472.2, R473.1, R487.2, R490.1, U$87.P$3, U$87.P$4
unnamed: IC60.6 (OUT), R480.1
unnamed: IC61.6 (OUT), JP57.3, R481.1, R488.2
unnamed: C414.2, C415.1, IC59.6 (OUT), R474.1, R487.1
unnamed: IC61.1 (RG), R483.1
unnamed: IC61.8 (RG), R483.2
unnamed: IC61.2 (-IN), JP57.2
unnamed: IC61.3 (+IN), JP58.2
unnamed: D203.C, D204.A, D206.A, JP57.1, R484.2
unnamed: R484.1, U$89.P$3, U$89.P$4
unnamed: D201.C, D202.A, D205.A, JP58.1, R485.2
unnamed: R485.1, U$89.P$1, U$89.P$2
unnamed: JP58.3, R486.2
unnamed: JP59.1, R472.1, R479.1
unnamed: R474.2, U$87.P$1, U$87.P$2
unnamed: IC60.2 (-IN), U$90.P$8 (DA)
unnamed: IC60.3 (+IN), U$90.P$9 (DB)
unnamed: C418.2, R491.2, U$90.P$10 (S4B)
unnamed: C418.1, R490.2, U$90.P$7 (S4A)
OUT10: K25.8 (S), K25.9 (S), U$88.P$3, U$88.P$4
SENSEI10: C412.1, R480.2, TP79.1; also elsewhere on the board
SENSEV10: C411.2, R481.2, TP80.1; also elsewhere on the board
SWITCH10: Q36.1 (G), R477.2; also elsewhere on the board
VCC: C406.1, C408.1, C410.2, C416.2, D198.C, D200.C, D202.C, D204.C, IC59.7 (V+), IC60.7 (V+), IC61.7 (V+), K25.1 (+), LED19.A, U$90.P$2 (EN), U$90.P$14 (V+), U$90.P$16 (A1); also elsewhere on the board
VDD: C405.1, C407.1, C409.2, C417.2, D199.A, D201.A, D203.A, IC59.4 (V-), IC60.4 (V-), IC61.4 (V-), U$90.P$3 (V-); also elsewhere on the board

Notices in the files:
parts and their libraries:
microbuilder: This work is placed in the public domain, and may be freely used for commercial and non-commercial work with the following conditions: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
SparkFun-DiscreteSemi: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
